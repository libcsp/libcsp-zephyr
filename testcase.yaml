## testcase.yaml
```yaml
tests:
  libcsp.subsec:
    integration_platforms:
      - qemu_cortex_m3
      - mps2/an385
    tags: libcsp
```
